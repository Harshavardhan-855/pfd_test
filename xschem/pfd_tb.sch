v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {pfd.sym} -520 -250 0 0 {name=x1}
C {pfd.sym} -130 -250 0 0 {name=x2}
C {pfd.sym} 230 -250 0 0 {name=x3}
